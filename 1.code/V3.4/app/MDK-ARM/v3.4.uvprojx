# Keil uVision project v3.4.uvprojx, settings and files
target v3.4 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: v3_4 +hex
  AfterMake: E:\KEIL\CORE\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin --output ./v3.4/v3_4.bin ./v3.4/v3_4.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,MQTTCLIENT_PLATFORM_HEADER=platform.h
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/digital;../BSP/extern_flash;../BSP/HAL_FLASH;../BSP/ioLibrary_Driver/Application/loopback;../BSP/ioLibrary_Driver/Ethernet;../BSP/ioLibrary_Driver/Ethernet/W5500;../BSP/ioLibrary_Driver/Internet/DHCP;../BSP/ioLibrary_Driver;../BSP/lfs;../BSP/msh;../BSP/env;../BSP/cJSON;../BSP/tinycrypt-latest/include;../BSP/CRC/crc;../BSP/STTS22HTR;../BSP/Filter_method;../BSP/ioLibrary_Driver/Internet/MQTT;../BSP/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src;../BSP/FlashDB/inc;../BSP/sfud/inc;../BSP/FlashDB/port/fal/inc;../BSP/FlashDB/port;../BSP/FlashDB;../BSP/ioLibrary_Driver/Internet/DNS;../BSP/ioLibrary_Driver/Internet/SNTP;../BSP/RTT;../BSP/OTA;../BSP/MQTT;..\BSP\MODBUS\inc;..\BSP\AT\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group flash
    ../BSP/extern_flash/: app_w25qxx.c app_w25qxx.h driver_w25qxx.c driver_w25qxx.h
    ../BSP/HAL_FLASH/: hal_flash.c hal_flash.h
  group Ethernet
    ../BSP/ioLibrary_Driver/: app_w5500.c app_w5500.h app_w5500_tcp_client.c app_w5500_tcp_client.h app_w5500_udp.c app_w5500_udp.h app_w5500_tcp_server.c app_w5500_tcp_server.h app_w5500_mqtt.c app_w5500_mqtt.h app_w5500_http.c app_w5500_http.h app_w5500_ntp.c app_w5500_ntp.h app_w5500_tcp_server_modbus.c app_w5500_tcp_server_modbus.h wiz_platform.c
    ../BSP/ioLibrary_Driver/Application/loopback/: loopback.c
    ../BSP/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../BSP/ioLibrary_Driver/Ethernet/W5500/: w5500.c
    ../BSP/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../BSP/ioLibrary_Driver/Internet/MQTT/: mqtt_interface.c MQTTClient.c
    ../BSP/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../BSP/ioLibrary_Driver/Internet/DNS/: dns.c
    ../BSP/ioLibrary_Driver/Internet/SNTP/: sntp.c
  group lfs
    ../BSP/lfs/: lfs.c lfs.h lfs_user.c lfs_user.h lfs_util.c lfs_util.h
  group msh
    ../BSP/msh/: msh.c msh.h
  group digital
    ../BSP/digital/: digital.c digital.h
  group env
    ../BSP/env/: temp.c temp.h INA226.c INA226.h env.c env.h
    ../../../../../V2.2/app/BSP/env/: STTS22HTR.c STTS22HTR.h
  group cJSON
    ../BSP/cJSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h cJSON_fieldManage.h
  group tinycrypt
    ../BSP/tinycrypt-latest/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
    ../BSP/tinycrypt-latest/include/: tinycrypt_config.h tiny_aes.h tiny_base64.h tiny_md5.h tiny_sha1.h tiny_sha2.h tinycrypt.h
  group CRC
    ../BSP/CRC/crc/: crc_poly.c crc8.c crc16.c crc32.c crc64.c
  group Filter
    ../BSP/Filter_method/: Filter_manager.c Filter_manager.h Average_Filter.c Average_Filter.h Clipping_Filter.c Clipping_Filter.h Kalman_Filter.c Kalman_Filter.h Median_Filter.c Median_Filter.h IIR_Filter.c IIR_Filter.h Compensation_Filter.c Compensation_Filter.h Filter_data_type.h
  group FlashDB
    ../BSP/sfud/src/: sfud.c sfud_sfdp.c
    ../BSP/sfud/port/: sfud_port.c
    ../BSP/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ../BSP/FlashDB/port/fal/src/: fal.c fal_flash.c fal_flash_sfud_port.c fal_partition.c fal_rtt.c
    ../BSP/FlashDB/port/fal/inc/: fal_cfg.h
    ../BSP/FlashDB/: app_flashdb.c app_flashdb.h
  group RTT
    ../BSP/RTT/: SEGGER_RTT.c SEGGER_RTT_Conf.h SEGGER_RTT.h log.h SEGGER_RTT_printf.c debug_print.h
  group OTA
    ../BSP/OTA/: ota.c ota.h
  group MQTT
    ../BSP/MQTT/: mqtt.c mqtt.h
  group modbus
    ../BSP/MODBUS/com/: mb.c
    ../BSP/MODBUS/inc/: mb.h mb_master_app.h mb_master_port.h mb_master_proc.h mb_slave_app.h mb_slave_port.h mb_slave_proc.h
    ../BSP/MODBUS/src-master/: mb_master_app.c mb_master_port.c mb_master_proc.c
    ../BSP/MODBUS/src-slave/: mb_slave_app.c mb_slave_port.c mb_slave_proc.c
  group AT
    ../BSP/AT/src/: AT_Function.c AT_HTTP.c AT_MQTT.c AT_RingBuf.c base64.c hmac_sha1.c lot_function.c onenet.c
software components: CMSIS:CORE 4.3.0
